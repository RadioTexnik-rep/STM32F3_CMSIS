# Keil uVision project Blink.uvprojx, settings and files
target F303C8T6 (6140000::V6.14::ARMCLANG)
  device: STM32F303C8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blink +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\CMSIS;..\Blink;.\Code\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group CMSIS
    ./CMSIS/: system_stm32f3xx.c
  group StartUp
    ./StartUp/: startup_stm32f303x8.s
  group Code
    ./Code/src/: hw_init.c main.c
